<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>value</key><value>500000</value></param>
<param><key>gui_hint</key><value>2,0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>10000</value></param>
<param><key>step</key><value>10000</value></param>
<param><key>stop</key><value>1000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cutoff2</value></param>
<param><key>value</key><value>100000</value></param>
<param><key>gui_hint</key><value>4,0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>10000</value></param>
<param><key>step</key><value>10000</value></param>
<param><key>stop</key><value>500000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>demod_gain</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>3,0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>868.1e6</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>868e6-10e5</value></param>
<param><key>step</key><value>10000</value></param>
<param><key>stop</key><value>868e6+10e5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>24</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>shift</value></param>
<param><key>value</key><value>200000</value></param>
<param><key>gui_hint</key><value>5,0</value></param>
<param><key>min_len</key><value>20</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>100000</value></param>
<param><key>stop</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subsampling</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>-30</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-0.5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/henry/sdr/sdr/TFA/raw2.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>n</key><value>subsampling</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>demod_gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value># -*- coding: utf-8 -*-
"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import math

ERROR = 1
INFO = 2
TRACE = 3


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, sample_rate=20000 , debug_level=0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Decoder Block',   # will show up in GRC
            in_sig=[np.byte],
            out_sig=[np.float32, np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.debug_level = debug_level
        self.sample_rate = sample_rate
        self.state = "idle"

        self.chunk_id = 0
        self.pulse_short_limit = 30   # default value for maximum length of a short bit in µs (valid for optimal rx quality)
        self.gap_short_limit = 30   #  default value for maximum length of a short bit in µs (valid for optimal rx quality)
        self.reset_limit = 500

        self.currentSymbols = np.empty(0, dtype=np.uint8)
        self.rawBuffer = np.empty(0, dtype=np.uint8)
        self.currentSymbolType = 0
        self.previousSymbolType = 0

        # sensor data
        self.identifier = 0
        self.temperature = 0
        self.humidity = 0
        self.battery_ok = False

    def debug(self, message, level=0):
        """Debug output depending on debug level."""
        if self.debug_level &gt;= level:
            print message

    @classmethod
    def crc8(cls, data):
        """Simple CRC-8 calculator"""
        generator = 0x31    # x^8 + x^5 + x^4 + 1
        crc = np.uint8(0)   # use uint8

        for currByte in data:
            crc ^= currByte
            for i in range(8):
                if (crc &amp; 0x80) != 0:
                    crc = np.uint8((crc &lt;&lt; 1) ^ generator)
                else:
                    crc &lt;&lt;= 1
        return crc

    def work(self, input_items, output_items):
        """The actual Decoder."""
        # pylint: disable=too-many-nested-blocks, too-many-statements, R0914, R0912, C0301

        rawChunk = input_items[0]
        self.rawBuffer = np.append(self.rawBuffer, rawChunk)

        # we need at least as many samples as is defined by reset_limit
        if self.rawBuffer.size*1e6/self.sample_rate &gt; self.reset_limit:

            # skip empty or zero-only chunks
            if (self.rawBuffer.size &gt; 0) and ((np.sum(self.rawBuffer) &gt; 0) or (self.currentSymbols.size &gt; 0)):

                self.currentSymbolType = self.rawBuffer[0]
                self.debug(("first raw sample", self.rawBuffer[0]), TRACE)
                self.debug(("last raw sample", self.rawBuffer[-1]), TRACE)

                # force edge at beginning an end of rawBuffer
                self.rawBuffer = np.insert(self.rawBuffer, 0, [1 - self.rawBuffer[0]])
                self.rawBuffer = np.append(self.rawBuffer, [1 - self.rawBuffer[-1]])

                self.chunk_id += 1
                self.debug(("Chunk", self.chunk_id), TRACE)
                #self.debug("rawBuffer", rawBuffer.size, rawBuffer)

                # calculate edges from raw data; insert one at beginning for sync
                edges = np.insert(np.diff(self.rawBuffer), 0, [0])
                # position (offset) of edges
                edge_positions = np.ravel(np.nonzero(edges))
                self.debug(("edge_positions:", edge_positions), TRACE)

                self.debug(("edges", edges[np.nonzero(edges)]), TRACE)

                if edge_positions.size &gt; 0:
                    # lengths of pulses and pauses are our symbols, convert to µs
                    symbols = np.diff(edge_positions)*1e6/self.sample_rate

                    # split symbols at packet boundary
                    symbols = np.array(np.split(symbols, np.ravel(np.where(symbols &gt; self.reset_limit))+1))
                    self.debug(("Symbols:", symbols.size, symbols), TRACE)
                    self.debug(("symbols.shape", symbols.shape[0]), TRACE)
                    self.debug(("state", self.state), TRACE)

                    # if symbols are split into 2+ arrays at packet boundary we
                    # have a valid frame
                    if symbols.shape[0] &gt; 1:
                        self.state = "frame"

                    # process all parts separately
                    for symbol_chunk in symbols:
                        self.debug(("state", self.state), TRACE)
                        if (symbols.size == 1) or self.state == "idle":
                            # skip leading inter-frame gap
                            symbol_chunk = symbol_chunk[1::]
                        if symbol_chunk.size &gt; 0:
                            self.debug(("symbol_chunk:", symbol_chunk.size, symbol_chunk), TRACE)
                            self.state = "frame"

                            # add first symbol to last from previous to reassemble separated pulses/gaps
                            if (self.currentSymbols.size &gt; 0) and (self.previousSymbolType == self.currentSymbolType):
                                self.currentSymbols[-1] += symbol_chunk[0]
                                symbol_chunk = symbol_chunk[1::]

                            self.currentSymbols = np.append(self.currentSymbols, symbol_chunk)

                            if self.currentSymbols[0] &gt; self.reset_limit:
                                self.currentSymbols = self.currentSymbols[1::]

                            self.debug(("currentSymbols:", self.currentSymbols.size, self.currentSymbols), TRACE)

                            # complete packet is determined by long gap at the end
                            if (self.currentSymbols.size &gt; 1) and (self.currentSymbols[-1] &gt; self.reset_limit):

                                # remove first few symbols
                                self.currentSymbols = self.currentSymbols[6:]

                                # sync pattern - about 75 bits
                                sync = self.currentSymbols[:2*75]
                                symbol_length = np.mean(np.sum(np.reshape(sync, (-1, 2)), axis=1))
                                if not math.isnan(symbol_length):
                                    baudrate = int(1e6/symbol_length)
                                    self.debug(("symbol_length:", symbol_length), TRACE)
                                    self.debug(("baudrate:", baudrate), TRACE)

                                    # determine start of data packet
                                    data_start = np.where(self.currentSymbols &gt; symbol_length*1.5)[0][0]
                                    self.debug(("data_start:", data_start), TRACE)

                                    # extract pulses
                                    pulses = self.currentSymbols[data_start:-1:2]

                                    # remove short pulses (they are just part of zeroes)
                                    pulses = np.where(pulses &lt; symbol_length, 0, pulses)

                                    # extract gaps
                                    gaps = self.currentSymbols[data_start+1:-1:2]

                                    self.debug(("Pulses:", pulses.size, pulses), TRACE)
                                    self.debug(("Gaps:", gaps.size, gaps), TRACE)

                                    # interleave pulses and gaps into one array like this [p, g, p, g, p, g]
                                    combined = np.empty(pulses.size + gaps.size, dtype=pulses.dtype)
                                    combined[0::2] = np.floor(pulses/symbol_length)
                                    combined[1::2] = np.ceil(gaps/symbol_length)

                                    self.debug(("combined:", combined.size, combined), TRACE)

                                    # FIXME - there must be a more elegant solution...
                                    rawBits = np.empty(0, dtype=np.uint8)
                                    for index, symbol in np.ndenumerate(combined):
                                        if symbol:
                                            if not index[0] % 2:
                                                rawBits = np.append(rawBits, np.ones(int(symbol), dtype=np.uint8))
                                            else:
                                                rawBits = np.append(rawBits, np.zeros(int(symbol), dtype=np.uint8))

                                    self.debug(("rawBits:", rawBits.size, rawBits), TRACE)

                                    # make sure we have at least 11 bytes
                                    if rawBits.size &gt;= 11*8:
                                        # use the first eleven bytes only, swap MSB and LSB, pack 8 bits into one byte, reverse order to compensate for 1st flip
                                        packet = np.packbits(rawBits[:11*8][::-1])[::-1]

                                        np.set_printoptions(formatter={'int':hex})
                                        self.debug(("packet:", packet.size, packet), INFO)
                                        np.set_printoptions(formatter=None)
                                        # check CRC8
                                        if self.crc8(packet[2:10]) == packet[10]:
                                            self.identifier = "{:02X}".format((packet[2]&lt;&lt;8) + packet[3])
                                            self.temperature = (packet[4] &amp; 0x0f) * 10 + ((packet[5]&gt;&gt;4) &amp; 0x0f) * 1 + (packet[5] &amp; 0x0f) * 0.1 - 40
                                            self.humidity = (packet[6] &amp; 0x7f)
                                            self.battery_ok = (packet[7]&gt;&gt;7) &amp; 0x01 == 0

                                            self.debug(("Identifier:", self.identifier), INFO)
                                            self.debug(("Battery ok:", self.battery_ok), INFO)
                                            print "Temperature: %02.1f°C" % self.temperature
                                            print "Humidity: %02i%%" % self.humidity
                                        else:
                                            self.debug("CRC-Check failed", ERROR)
                                    else:
                                        self.debug("Invalid packet length", ERROR)
                                else:
                                    self.debug("Symbol length error", ERROR)    

                                # done with this packet
                                self.currentSymbols = np.empty(0, dtype=np.uint8)
                            else:
                                self.debug("Waiting for more data", TRACE)
                        else:
                            self.debug("skipping empty chunk", INFO)
                            self.state = "idle"
                else:
                    self.debug("no edges in chunk", INFO)
                self.previousSymbolType = self.rawBuffer[-2]
            else:
                #self.debug("Chunk is empty or contains no edges")
                self.state = "idle"
            # all done, delete current rawBuffer
            self.rawBuffer = np.empty(0, dtype=np.uint8)
        else:
            # wait for more samples
            self.debug("filling rawBuffer", TRACE)

        output_items[0][:] = self.temperature
        output_items[1][:] = self.humidity
        return len(output_items[0])
</value></param>
<param><key>debug_level</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sample_rate</key><value>samp_rate/decimation/subsampling</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>+shift</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>cutoff*2</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>6,0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>alpha1</key><value>0.1</value></param>
<param><key>size</key><value>20000</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"squelch_sob"</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>100000</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,2,7,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>tr_level</key><value>-40.0</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"squelch_sob"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.02</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>4,0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>color1</key><value>("blue", "red")</value></param>
<param><key>label1</key><value>Temperature</value></param>
<param><key>unit1</key><value>Celsius</value></param>
<param><key>color2</key><value>("blue", "red")</value></param>
<param><key>label2</key><value>Humidity</value></param>
<param><key>unit2</key><value>%</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>-40</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>int(samp_rate/100/decimation)</value></param>
<param><key>srate</key><value>samp_rate/decimation</value></param>
<param><key>tr_chan</key><value>2</value></param>
<param><key>tr_level</key><value>0.005</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"squelch_sob"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>100000</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,1,7,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>int_min</key><value>-100</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq-shift</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
