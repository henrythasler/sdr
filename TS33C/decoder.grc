<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>value</key><value>20e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subsampling</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-0.5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>/home/henry/sdr/sdr/TS33C/TS33C_samples.dat</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/henry/sdr/sdr/TS33C/TS33C_raw.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>subsampling</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>.150</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>.05</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/henry/sdr/sdr/TS33C/TS33C_bitstream.wav</value></param>
<param><key>samp_rate</key><value>int(samp_rate/1)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/henry/sdr/sdr/TS33C/TS33C_bytes.wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>int(samp_rate/subsampling)</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>decoder</value></param>
<param><key>_source_code</key><value># -*- coding: utf-8 -*-
"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import pmt


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, sample_rate=1.0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Decoder Block',   # will show up in GRC
            in_sig=[np.byte],
            out_sig=[np.byte]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.sample_rate = sample_rate
        self.state = 0
        self.absolute_position = 0
        self.decoded_bits = np.array([0])

        self.chunk_id = 0
        self.SAMPLERATE = 200000  # in Hz
        self.short_limit = 775   # maximum length of a short bit in µs
        self.reset_limit = 2*self.short_limit

        self.currentSymbols = np.empty(0, dtype=np.uint8)


    def work(self, input_items, output_items):
        """example: multiply with constant"""

        
        rawChunk = input_items[0]

        # skip empty or zero-only chunks    
        if (rawChunk.size &gt; 0) and (np.sum(rawChunk) &gt; 0) :

          #print("first raw sample",rawChunk[0])
          #print("last raw sample",rawChunk[-1])

          # force edge at beginning an end of rawChunk
          rawChunk = np.insert(rawChunk,0,[1 - rawChunk[0]])
          rawChunk = np.append(rawChunk, [1 - rawChunk[-1]])

          self.chunk_id += 1
          #print("Chunk", self.chunk_id)

          # calculate edges from raw data; insert one at beginning for sync
          edges = np.insert(np.diff(rawChunk),0,[0])
          # position (offset) of edges
          edge_positions = np.ravel(np.nonzero(edges))
          #print("edge_positions:", edge_positions)

          #print("edges", edges[np.nonzero(edges)])

          if edge_positions.size &gt; 0:
            # lengths of pulses and pauses are our symbols, convert to µs
            symbols = np.diff(edge_positions)*1e6/self.SAMPLERATE
            # split symbols at packet boundary
            symbols = np.split(symbols, np.ravel(np.where(symbols&gt;self.reset_limit))+1)
            #print("Symbols:", symbols)

            # process all parts separately
            for symbol_chunk in symbols:
              if symbol_chunk.size &gt; 0:
                #print("symbol_chunk:", symbol_chunk.size,symbol_chunk)

                # add first symbol to last from previous to reassemble separated pulses/gaps
                if self.currentSymbols.size &gt; 0: 
                  self.currentSymbols[-1] += symbol_chunk[0]
                  symbol_chunk = symbol_chunk[1::] 

                self.currentSymbols = np.append(self.currentSymbols, symbol_chunk)

                print("self.currentSymbols:", self.currentSymbols.size,self.currentSymbols)

                # complete packet is determined by long gap at the end 
                if self.currentSymbols[-1] &gt; self.reset_limit:
                  # extract pulses
                  pulses = self.currentSymbols[0::2]

                  # extract gaps
                  gaps = self.currentSymbols[1::2]

                  # set short gaps to zero as per decoding rule to remove them later
                  gaps = np.where(gaps&gt;self.short_limit,gaps,0)

                  # remove packet pause
                  gaps = np.where(gaps&gt;self.reset_limit,0,gaps)

                  print("Pulses:", pulses.size,pulses)
                  print("Gaps:", gaps.size, gaps)

                  # interleave pulses and gaps into one array like this [p, g, p, g, p, g]
                  combined = np.empty(pulses.size + gaps.size, dtype=pulses.dtype)
                  combined[0::2] = pulses
                  combined[1::2] = gaps

                  # remove short gaps
                  combined = combined[np.where(combined&gt;0)]
                  print("combined:", combined.size,combined)

                  # convert pulse/gap-width to bits as per decoding rule
                  rawBits = np.where(combined&gt;self.short_limit,0,1)
                  print("rawBits:", rawBits.size,rawBits)

                  # pack raw bits into bytes
                  rawPacket = np.packbits(rawBits)
                  np.set_printoptions(formatter={'int':hex})
                  print("raw packet:", rawPacket.size, rawPacket)
                  np.set_printoptions(formatter=None)
                  
                  if rawPacket.size &gt;= 10:                  
                    # prepare final packet
                    packet = np.empty(0, dtype=np.uint8)

                    # decode all 10 bytes
                    for i in range(0, 8):
                      # do some magic
                      item = np.uint8(rawPacket[i+i/8] &lt;&lt; (i%8))
                      item |= np.uint8(rawPacket[i+i/8+1] &gt;&gt; (8 - i%8))
                      # reverse and invert bits; add to packet
                      packet = np.append(packet, np.uint8(int('{:08b}'.format(item)[::-1],2)^0xff))

                    np.set_printoptions(formatter={'int':hex})
                    print("packet:", packet.size, packet)
                    np.set_printoptions(formatter=None)

                    # check for correct header-byte
                    if packet[0] == 0x9f:
                      channel = (packet[1] &gt;&gt; 5) &amp; 0x0F
                      if channel &gt;= 5:
                        channel -= 1
                      rc = packet[1] &amp; 0x0F
                      temp = (packet[5] &amp; 0x0F) * 100 + ((packet[4] &amp; 0xF0) &gt;&gt; 4) * 10 + (packet[4] &amp; 0x0F)
                      if ((packet[5]&gt;&gt;7) &amp; 0x01) == 0:
                        temp = -temp
                      battery_ok = (packet[5]&gt;&gt;6) &amp; 0x01
                      humidity = ((packet[6] &amp; 0xF0) &gt;&gt; 4) * 10 + (packet[6] &amp; 0x0F)

                      print("Channel:", channel)
                      print("Rolling Code:", rc)
                      print("Battery:", battery_ok)
                      print("Temperature:", temp/10.)
                      print("Humidity:", humidity)
                    else:
                      print("Unknown Header")
                  else:
                    print("packet too short")
                  # done with this packet
                  self.currentSymbols = np.empty(0, dtype=np.uint8)
                else:
                  print("Waiting for more data")
              else:
                print("skipping empty chunk")
          else:
            print("no edges in chunk")
        else:
          #print("Chunk is empty or contains no edges")
          pass


        output_items[0][:] = 0
        return len(output_items[0])
</value></param>
<param><key>sample_rate</key><value>1.0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>edge_detector</value></param>
<param><key>_source_code</key><value># -*- coding: utf-8 -*-
"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Edge Detector Block',   # will show up in GRC
            in_sig=[np.byte],
            out_sig=[np.byte]
        )
        self.rawBuffer = np.empty(0, dtype=np.uint8)

    def work(self, input_items, output_items):
        """example: multiply with constant"""

        rawChunk = input_items[0]
        edges = np.insert(np.diff(rawChunk),0,[0])
        output_items[0][:] = edges
        return len(output_items[0])
</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>cutoff_freq</key><value>cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>cutoff*2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>tr_level</key><value>-40.0</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.02</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>alpha1</key><value>.4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>width1</key><value>10</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>marker2</key><value>0</value></param>
<param><key>width2</key><value>2</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>4240</value></param>
<param><key>srate</key><value>64</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>tr_level</key><value>0.25</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>alpha1</key><value>.4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>width1</key><value>10</value></param>
<param><key>size</key><value>1000/subsampling</value></param>
<param><key>srate</key><value>64</value></param>
<param><key>tr_level</key><value>0.25</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_1</source_block_id><sink_block_id>blocks_wavfile_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_1_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_char_to_float_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>edge_detector</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decoder</source_block_id><sink_block_id>blocks_char_to_float_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>edge_detector</source_block_id><sink_block_id>blocks_char_to_float_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
