<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>value</key><value>20e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subsampling</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-0.5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/henry/sdr/sdr/berner/samples.dat</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/henry/sdr/sdr/berner/raw.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>n</key><value>subsampling</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>.150</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>.05</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/henry/sdr/sdr/TS33C/TS33C_bitstream.wav</value></param>
<param><key>samp_rate</key><value>int(samp_rate/1)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0_0</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>file</key><value>/home/henry/sdr/sdr/berner/readme-example.wav</value></param>
<param><key>nchan</key><value>4</value></param>
<param><key>samp_rate</key><value>int(samp_rate/1)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_1</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/henry/sdr/sdr/TS33C/temp_log.wav</value></param>
<param><key>samp_rate</key><value>1</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>decoder</value></param>
<param><key>_source_code</key><value># -*- coding: utf-8 -*-
"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import pmt

ERROR = 1
INFO = 2
TRACE = 3


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, sample_rate=20000 , debug_level=0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Decoder Block',   # will show up in GRC
            in_sig=[np.byte],
            out_sig=[np.float32, np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.debug_level = debug_level
        self.sample_rate = sample_rate
        self.state = "idle"

        self.chunk_id = 0
        self.pulse_short_limit = 775   # default value for maximum length of a short bit in µs (valid for optimal rx quality)
        self.gap_short_limit = 775   #  default value for maximum length of a short bit in µs (valid for optimal rx quality)
        self.reset_limit = 2*self.gap_short_limit

        self.currentSymbols = np.empty(0, dtype=np.uint8)
        self.rawBuffer = np.empty(0, dtype=np.uint8)
        self.currentSymbolType = 0
        self.previousSymbolType = 0

        self.temperature = 0
        self.humidity = 0

    def debug(self, message, level=0):
        if self.debug_level &gt;= level:
            print message


    def work(self, input_items, output_items):
        """example: decode TS33C"""

        rawChunk = input_items[0]
        self.rawBuffer = np.append(self.rawBuffer, rawChunk)

        # we need at least as many samples as is defined by reset_limi
        if self.rawBuffer.size*1e6/self.sample_rate &gt; self.reset_limit:

            # skip empty or zero-only chunks
            if (self.rawBuffer.size &gt; 0) and ((np.sum(self.rawBuffer) &gt; 0) or (self.currentSymbols.size &gt; 0)):

                self.currentSymbolType = self.rawBuffer[0]
                self.debug(("first raw sample", self.rawBuffer[0]), TRACE)
                self.debug(("last raw sample", self.rawBuffer[-1]), TRACE)

                # force edge at beginning an end of rawBuffer
                self.rawBuffer = np.insert(self.rawBuffer, 0, [1 - self.rawBuffer[0]])
                self.rawBuffer = np.append(self.rawBuffer, [1 - self.rawBuffer[-1]])

                self.chunk_id += 1
                self.debug(("Chunk", self.chunk_id), TRACE)
                #self.debug("rawBuffer", rawBuffer.size, rawBuffer)

                # calculate edges from raw data; insert one at beginning for sync
                edges = np.insert(np.diff(self.rawBuffer), 0, [0])
                # position (offset) of edges
                edge_positions = np.ravel(np.nonzero(edges))
                self.debug(("edge_positions:", edge_positions), TRACE)

                self.debug(("edges", edges[np.nonzero(edges)]), TRACE)

                if edge_positions.size &gt; 0:
                    # lengths of pulses and pauses are our symbols, convert to µs
                    symbols = np.diff(edge_positions)*1e6/self.sample_rate

                    # split symbols at packet boundary
                    symbols = np.array(np.split(symbols, np.ravel(np.where(symbols &gt; self.reset_limit))+1))
                    self.debug(("Symbols:", symbols.size, symbols), TRACE)
                    self.debug(("symbols.shape", symbols.shape[0]), TRACE)
                    self.debug(("state", self.state), TRACE)
                    if symbols.shape[0] &gt; 1:
                        self.state = "frame"

                    # process all parts separately
                    for symbol_chunk in symbols:
                        self.debug(("state", self.state), TRACE)
                        if (symbols.size == 1) or self.state == "idle":
                            # skip leading inter-frame gap
                            symbol_chunk = symbol_chunk[1::]
                        if symbol_chunk.size &gt; 0:
                            self.debug(("symbol_chunk:", symbol_chunk.size, symbol_chunk), TRACE)
                            self.state = "frame"

                            # add first symbol to last from previous to reassemble separated pulses/gaps
                            if (self.currentSymbols.size &gt; 0) and (self.previousSymbolType == self.currentSymbolType):
                                self.currentSymbols[-1] += symbol_chunk[0]
                                symbol_chunk = symbol_chunk[1::]

                            self.currentSymbols = np.append(self.currentSymbols, symbol_chunk)

                            if self.currentSymbols[0] &gt; self.reset_limit:
                                self.currentSymbols = self.currentSymbols[1::]

                            self.debug(("currentSymbols:", self.currentSymbols.size, self.currentSymbols), TRACE)

                            # complete packet is determined by long gap at the end
                            if (self.currentSymbols.size &gt; 1) and (self.currentSymbols[-1] &gt; self.reset_limit):

                                # extract pulses
                                pulses = self.currentSymbols[0::2]

                                # extract gaps
                                gaps = self.currentSymbols[1::2]

                                # remove packet pause
                                gaps = np.where(gaps &gt; self.reset_limit, 0, gaps)

                                # calculate histogram to determine length of short and long pulses
                                pulse_histogram = np.histogram(pulses, "auto")

                                # calculate histogram to determine length of short and long gaps; leave out packet pause
                                gap_histogram = np.histogram(gaps[np.where(gaps &gt; 0)], "auto")

                                # derive limits for short pulses/gaps from histogram. Use value in the middle between short and long
                                self.pulse_short_limit = pulse_histogram[1][pulse_histogram[1].size/2]
                                self.gap_short_limit = gap_histogram[1][gap_histogram[1].size/2]

                                self.debug(("Pulses:", pulses.size, pulses), TRACE)
                                self.debug(("Pulse Histogram", pulse_histogram), TRACE)
                                self.debug(("pulse_short_limit", self.pulse_short_limit), TRACE)
                                self.debug(("Gaps:", gaps.size, gaps), TRACE)
                                self.debug(("Gaps Histogram", gap_histogram), TRACE)
                                self.debug(("gap_short_limit", self.gap_short_limit), TRACE)

                                # interleave pulses and gaps into one array like this [p, g, p, g, p, g]
                                combined = np.empty(pulses.size + gaps.size, dtype=pulses.dtype)
                                combined[0::2] = pulses
                                combined[1::2] = gaps

                                self.debug(("combined:", combined.size, combined), TRACE)

                                # convert pulse/gap-width to bits as per decoding rule
                                rawBits = np.empty(combined.size, dtype=np.uint8)
                                self.debug(("rawBits.size", rawBits.size), TRACE)
                                rawBits[0::2] = np.where(combined[0::2] &lt; self.pulse_short_limit, 1, 0)
                                rawBits[1::2] = np.where(combined[1::2] &lt; self.gap_short_limit, 255, 0)

                                # remove short gaps
                                rawBits = rawBits[np.where(rawBits &lt;= 1)]
                                self.debug(("rawBits:", rawBits.size, rawBits), TRACE)

                                # prepare boolean mask for parity bits (every 9th bit)
                                parityMask = np.mod(np.arange(rawBits.size)+1, 9) == 0

                                # extract parity bits as boolean array
                                parityBits = np.extract(parityMask, rawBits) == 1
                                # extract packet bits
                                packetBits = np.extract(np.invert(parityMask), rawBits) == 1

                                if (packetBits.size % 8) == 0:
                                    # swap MSB and LSB, invert Bits, pack 8 bits into one byte, reverse order to compensate for 1st flip
                                    packet = np.packbits(np.invert(packetBits[::-1]))[::-1]

                                    np.set_printoptions(formatter={'int':hex})
                                    self.debug(("packet:", packet.size, packet), INFO)
                                    # calculate parity of each byte by splitting the bits into reversed and inverted 8-bit parts and 
                                    # calculate the sum of set bits; 
                                    packetParity = (np.sum(np.split(np.invert(packetBits[::-1]), np.arange(8, packetBits.size, 8)), axis=1)[::-1] % 2) == 0

                                    self.debug(("packetParity:", packetParity.size, packetParity), TRACE)
                                    np.set_printoptions(formatter=None)

                                    # check parity of packet
                                    if np.array_equal(packetParity, parityBits):
                                        # check for correct sensor type and header-byte
                                        if (packet.size == 10) and (packet[0] == 0x9f):
                                            channel = (packet[1] &gt;&gt; 5) &amp; 0x0F
                                            if channel &gt;= 5:
                                                channel -= 1
                                            rollingCode = packet[1] &amp; 0x0F
                                            temp = (packet[5] &amp; 0x0F) * 100 + ((packet[4] &amp; 0xF0) &gt;&gt; 4) * 10 + (packet[4] &amp; 0x0F)
                                            if ((packet[5]&gt;&gt;7) &amp; 0x01) == 0:
                                                temp = -temp
                                            self.temperature = temp/10.
                                            battery_ok = (packet[5]&gt;&gt;6) &amp; 0x01
                                            self.humidity = ((packet[6] &amp; 0xF0) &gt;&gt; 4) * 10 + (packet[6] &amp; 0x0F)

                                            self.debug(("Channel:", channel), INFO)
                                            self.debug(("Rolling Code:", rollingCode), INFO)
                                            self.debug(("Battery:", battery_ok), INFO)
                                            print("Temperature:", self.temperature)
                                            print("Humidity:", self.humidity)
                                        else:
                                            self.debug("Unknown Sensor or Header", ERROR)
                                    else:
                                        self.debug("Parity check failed", ERROR)
                                else:
                                    self.debug("Invalid packet length", ERROR)
                                # done with this packet
                                self.currentSymbols = np.empty(0, dtype=np.uint8)
                            else:
                                self.debug("Waiting for more data", TRACE)
                        else:
                            self.debug("skipping empty chunk", INFO)
                            self.state = "idle"
                else:
                    self.debug("no edges in chunk", INFO)
                self.previousSymbolType = self.rawBuffer[-2]
            else:
                #self.debug("Chunk is empty or contains no edges")
                self.state = "idle"
            # all done, delete current rawBuffer
            self.rawBuffer = np.empty(0, dtype=np.uint8)
        else:
            # wait for more samples
            self.debug("filling rawBuffer", TRACE)

        output_items[0][:] = self.temperature
        output_items[1][:] = self.humidity
        return len(output_items[0])
</value></param>
<param><key>debug_level</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sample_rate</key><value>20000</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>cutoff_freq</key><value>cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>cutoff*2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>tr_level</key><value>-40.0</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.02</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>color1</key><value>("blue", "red")</value></param>
<param><key>label1</key><value>Temperature</value></param>
<param><key>unit1</key><value>°C</value></param>
<param><key>color2</key><value>("blue", "red")</value></param>
<param><key>label2</key><value>Humidity</value></param>
<param><key>unit2</key><value>%</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>-40</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>int(samp_rate/100)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.2</value></param>
<param><key>ymin</key><value>-.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>alpha1</key><value>.4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>424</value></param>
<param><key>srate</key><value>64</value></param>
<param><key>tr_level</key><value>0.25</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decoder</source_block_id><sink_block_id>blocks_wavfile_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decoder</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decoder</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
